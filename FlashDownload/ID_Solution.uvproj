# Keil uVision project ID_Solution.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FLASH +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\Include_Files;.\StdPeriph_Driver\inc;.\CMSIS;.\FATFS_V0.08A\src;.\IMAGE;.\IMAGE_name;.\IMAGE_ETC;.\IMAGE_OVAL;.\IMAGE_NUMERIC;.\IMAGE_GRAPH;.\IMAGE_ETHERNET;.\IMAGE_CH2_CH4
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SourceFiles
    ./Source_Files/: main.c NandInterface.c NAND.c Initialize.c sdio_sd.c
  group IncludeFiles
    ./Include_Files/: Display.h Initialize.h Interrupt.h Main.h NandInterface.h stm32f10x_conf.h NAND.h tft.h RTC_Time.h serial.h Flash.h Watchdog.h DAC7512Interface.h Communication.h Button.h ReDisplay.h NANDDisplay.h
  group STD_Periph_Lib
    ./StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./: startup_stm32f10x_hd.s
  group FATFS_V0.08A
    ./FATFS_V0.08A/src/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Image
    ./IMAGE/: BELL_30x30.h CAUTION_40x32.h Cl_40x40.h SD_30x30.h WORKING_35x30.h
