# Keil uVision project ID_Solution.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ID_Solution +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\Include_Files;.\StdPeriph_Driver\inc;.\CMSIS;.\FATFS_V0.08A\src;.\Image;.\LwIP\system;.\LwIP\system\arch;.\LwIP\src\include;.\LwIP\src\include\ipv4;.\LwIP\src\include\lwip;.\LwIP\src\include\netif;.\LwIP\src\include\posix;.\LwIP\src\include\posix\sys;.\LwIP\src\core;.\Inc_ethernet;./Drivers/STM32F1xx_HAL_Driver/Inc;./Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;./Drivers/CMSIS/Device/ST/STM32F1xx/Include;./Drivers/CMSIS/Include;.
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SourceFiles
    ./Source_Files/: Display.c Initialize.c Interrupt.c main.c NandInterface.c NAND.c Tft.c RTC_Time.c serial.c Flash.c Watchdog.c DAC7512Interface.c Communication.c Button.c NANDDisplay.c CurrentSorceTrans.c MicroSd.c sdio_sd.c eeprom.c display_icon.c icon_ch2_ch4.c ReDisplay_ch2.c display_update.c ui_mode.c ReDisplay_ch1.c ReDisplay_ch4.c
  group IncludeFiles
    ./Include_Files/: Display.h Initialize.h Interrupt.h Main.h NandInterface.h stm32f10x_conf.h NAND.h tft.h RTC_Time.h serial.h Flash.h Watchdog.h DAC7512Interface.h Communication.h Button.h ReDisplay.h NANDDisplay.h history.h
  group STD_Periph_Lib
    ./StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_i2c.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./: startup_stm32f10x_hd.s
  group FATFS_V0.08A
    ./FATFS_V0.08A/src/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group LWIP_CORE
    ./LwIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LwIP/src/netif/: etharp.c ethernetif.c slipif.c
  group Ethernet
    ./source_ethernet/: app_ethernet.c enc28j60.c main_ethernet.c modbus_client.c ethernetif_1.c system_stm32f1xx.c stm32f1xx_it.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dac.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_dac_ex.c stm32f1xx_ll_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c
