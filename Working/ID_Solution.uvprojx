# Keil uVision project ID_Solution.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ID_Solution +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\Include_Files;.\StdPeriph_Driver\inc;.\CMSIS;.\FATFS_V0.08A\src;.\Image
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SourceFiles
    ./Source_Files/: Display.c Initialize.c Interrupt.c main.c NandInterface.c NAND.c Tft.c RTC_Time.c serial.c Flash.c Watchdog.c DAC7512Interface.c Communication.c Sensor_Manager.c sensor_ph.c sensor_ec.c sensor_autodetect.c sensor_adc.c Adc_Read.c Button.c ReDisplay.c NANDDisplay.c CurrentSorceTrans.c MicroSd.c sdio_sd.c eeprom.c display_icon.c ReDisplay_ch2.c display_update.c ui_mode.c ReDisplay_ch1.c ReDisplay_ch4.c
  group IncludeFiles
    ./Include_Files/: Display.h Initialize.h Interrupt.h Main.h NandInterface.h stm32f10x_conf.h NAND.h tft.h RTC_Time.h serial.h Flash.h Watchdog.h DAC7512Interface.h Communication.h Button.h ReDisplay.h NANDDisplay.h
  group STD_Periph_Lib
    ./StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_i2c.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./: startup_stm32f10x_hd.s
  group FATFS_V0.08A
    ./FATFS_V0.08A/src/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
software components: CMSIS:CORE 5.6.0
